<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LCD.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\..\Downloads\uart.ewp</path>
    </project>
    <batchBuild />
</workspace>
